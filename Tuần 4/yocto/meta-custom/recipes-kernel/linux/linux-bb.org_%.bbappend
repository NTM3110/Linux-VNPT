# FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# SRC_URI += "file://0001-switch-to-cpsw.patch"
